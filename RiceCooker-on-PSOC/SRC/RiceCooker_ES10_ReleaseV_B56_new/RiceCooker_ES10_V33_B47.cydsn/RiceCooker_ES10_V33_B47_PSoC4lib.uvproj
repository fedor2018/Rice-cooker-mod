# Keil uVision project RiceCooker_ES10_V33_B47_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: RiceCooker_ES10_V33_B47_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Opamp.c Opamp.h Opamp_PM.c PGA_Pos.c PGA_Pos.h PGA_Pos_aliases.h PGA_Neg.c PGA_Neg.h PGA_Neg_aliases.h PGA_Out.c PGA_Out.h PGA_Out_aliases.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h Vrtd.c Vrtd.h Vrtd_aliases.h Comp_Neg.c Comp_Neg.h Comp_Neg_aliases.h Comp_Pos.c Comp_Pos.h Comp_Pos_aliases.h PWM_Out.c PWM_Out.h PWM_Out_aliases.h CLK.c CLK.h isr_50ms.c isr_50ms.h PWM.c PWM.h PWM_PM.c Timer.c Timer.h Timer_PM.c LCD_Seg.c LCD_Seg.h LCD_Seg_PM.c ST_Switch.c ST_Switch.h ST_Switch_aliases.h isr_button.c isr_button.h UART.c UART.h UART_SPI_UART.h UART_SPI_UART.c UART_SPI_UART_INT.c UART_PM.c UART_UART.c UART_BOOT.c UART_UART_BOOT.c UART_SPI_UART_PVT.h Clock_1.c Clock_1.h isr_200ms.c isr_200ms.h isr_1000ms.c isr_1000ms.h Comp.h Comp.c Comp_PM.c I2C.c I2C.h I2C_I2C.h I2C_I2C_INT.c I2C_I2C.c I2C_I2C_BOOT.c I2C_I2C_MASTER.c I2C_I2C_SLAVE.c I2C_PM.c I2C_BOOT.c I2C_I2C_PVT.h LCD_Seg_Com_aliases.h LCD_Seg_Seg_aliases.h UART_SCB_IRQ.c UART_SCB_IRQ.h UART_SCBCLK.c UART_SCBCLK.h UART_tx.c UART_tx.h UART_tx_aliases.h UART_RX_WAKEUP_IRQ.c UART_RX_WAKEUP_IRQ.h UART_rx_wake.c UART_rx_wake.h UART_rx_wake_aliases.h I2C_SCB_IRQ.c I2C_SCB_IRQ.h I2C_SCBCLK.c I2C_SCBCLK.h I2C_scl.c I2C_scl.h I2C_scl_aliases.h I2C_sda.c I2C_sda.h I2C_sda_aliases.h ADC.c ADC.h ADC_PM.c ADC_INT.c ADC_intClock.c ADC_intClock.h ADC_IRQ.c ADC_IRQ.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: RiceCooker_ES10_V33_B47_PSoC4lib (library)
